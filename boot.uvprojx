# Keil uVision project boot.uvprojx, settings and files
target flasher_stub (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: flasher_stub
  AfterMake: fromelf --bin !L --output RDA5981_Stub.bin
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 wLevel=1
  c define: UNO_81C_U04 TDEFL_LESS_MEMORY
  c include: ./hal/rda;./hal/rda/device/rda5981;./main
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT9: RAM 0x110000 size 0x10000
  scatter file: .\bootloader.sct
  group main
    ./main/: main.c retarget.c
    ../OpenBK7231T_App/libraries/miniz/: miniz.c miniz_tdef.c miniz_tinfl.c
  group HAL
    ./hal/rda/: board.c drv_uart.c rda_api.c
    ./hal/rda/device/rda5981/: system_rda5981.c
    ./hal/rda/device/TOOLCHAIN_ARM_STD/: startup_rda5981.s
